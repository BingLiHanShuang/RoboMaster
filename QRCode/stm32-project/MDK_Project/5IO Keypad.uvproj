# Keil uVision project 5IO Keypad.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 5IO Keypad +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Lib;..\Lib\CMSIS;..\Lib\inc;..\User
  memory RVCT4: ROM 0x8000000 size 0x33800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Lib/: startup_stm32f10x_hd.s
  group Lib
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_tim.c
    ../Lib/CMSIS/: core_cm3.c system_stm32f10x.c
  group User
    ../User/: Main.c stm32f10x_it.c usart.c User_systick.c protobuf-c.c protocol.pb-c.c protocol.c systimer.c
